# Keil uVision project secondary_bootloader.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M3") CLOCK(12800000) ELITTLE
  output: secondary_bootloader +hex
  AfterMake: fromelf.exe --bin -o secondary_bootloader.bin ./output/secondary_bootloader.axf
  AfterMake: .\scripts\copy.bat 3_app
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/rom/inc;sdk/bundles/rom/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing20;sdk/src/Tools;sdk/src;.\src;.\src\IAP;.\src\IAP_BSP
  asm define: EFLASH_SEC_SIZE=4096
  library: MicroLIB
  memory RVCT4: ROM 0x2002000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group APP
    ./src/: main.c crc16.c interface.c
  group StartUP
    ./src/: startup_ing2000.s
  group BSP
    ./sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_pte.c peripheral_usb.c
  group IAP_bsp
    ./src/IAP_BSP/: bsp_usb_hid_iap.c
  group IAP
    ./src/IAP/: IAP.c IAP_Application.c IAP_Bootloader.c IAP_Flash_WP.c IAP_Transport.c
software components: CMSIS:CORE 4.3.0
