# Keil uVision project app.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M3") CLOCK(12800000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe --bin -o app.bin ./output/app.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/rom/inc;sdk/bundles/rom/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing20;sdk/src/Tools;sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x200a000 size 0x76000
  memory RVCT9: RAM 0x20004840 size 0x77c0
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing2000.s
    sdk/bundles/rom/ING208xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_asdm.c peripheral_dma.c peripheral_i2s.c peripheral_keyscan.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
software components: CMSIS:CORE 4.3.0
