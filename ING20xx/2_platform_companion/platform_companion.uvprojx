# Keil uVision project platform_companion.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x2000000,0x00200000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: platform_companion +hex
  AfterMake: fromelf.exe --bin -o platform_companion.bin ./output/platform_companion.axf
  AfterMake: python ./scripts/run_post_build.py --address 0x200A000 --app_name 3_app --sdk_path "D:\Program Files\ING_SDK"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: sdk\bundles\rom\inc;sdk\bundles\rom\inc\os;sdk\src\BSP;sdk\src\FWlib;sdk\src\StartUP\ing20;sdk\src\Tools;sdk\src
  asm define: EFLASH_SEC_SIZE=4096
  library: MicroLIB
  memory RVCT4: ROM 0x2004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x200
  memory RVCT10: RAM 0x20004420 size 0x500
  link misc: --keep=main.o(*) --keep=*.*(i.platform_*) --keep=*.*(i.hci*) --keep=*.*(i.gap_*)
--keep=*.*(i.ll_*)
  group APP
    ./src/: main.c ing920_platform_lib.o
  group StartUP
    ./src/: startup_ing92000.s
  group FWlib
    sdk/src/FWlib/: peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
software components: CMSIS:CORE 6.1.0
